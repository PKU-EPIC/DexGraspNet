Commit message: Clean

File: grasp_generation/table/table.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- removed link box
- added link table, mass 500; collision mesh filename=table.obj; visual mesh filename=table.obj
